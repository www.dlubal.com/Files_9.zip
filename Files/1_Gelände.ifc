Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: 2_Gelände
Time: 2025-05-16T06:35:55
Author: Andreas Hörold
Organization: Dlubal Software GmbH
Written by: IfcOpenShell 0.7.0
Made in: IfcOpenShell 0.7.0
Comment: Owner history
Comment: Project local system and geometric representation context
Comment: Units
Comment: Project
Comment: Materials
Comment: Surface 5
Comment: Surface 4
Comment: Surface 2
Comment: Surface 1
Comment: Surface 3
Comment: Rostislav Krc - Dlubal software, Inc. - 2019

# IfcBuildingElementProxy (5)
In: 2_Gelände
Material: S275JR | DB SE-A:2007-10
Name
Surface 5
Surface 4
Surface 2
Surface 1
Surface 3

# Material: S275JR | DB SE-A:2007-10
Material properties - Young modulus: 210000000000 N/m2; Shear modulus: 81000000000 N/m2; Density: 7850 kg/m3; Poisson's ratio: 0.3; Thermal expansion coefficient: 0.000012 1/C
